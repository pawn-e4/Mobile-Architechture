Commit message: Added new version with keyboard control

File: install/smart_car/share/smart_car/urdf/smartcar.urdf (robot description, URDF)
Before this commit: robot smart_car, 11 links, 10 joints
Joints:
- joint sllidar_mount_joint: origin xyz=0 0 0 rpy=0 0 0 -> xyz=0.1285 0 0.10 rpy=0 0 0
